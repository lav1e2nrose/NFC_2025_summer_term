# Keil uVision project Lab 8.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Lab 8 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Program Files\Keil_v5\C51\INC
  group Source Group 1
    ./: STARTUP.A51 main.c oled.c AT24C02.c PN532.c I2C.c utils.c menu.c bluetooth.c bluetooth.h
