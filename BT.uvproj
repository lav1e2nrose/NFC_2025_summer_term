# Keil uVision project BT.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: BT +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 uart.c bluetooth.c ui.c main.c utils.c uart.h bluetooth.h ui.h utils.h AT24C02.c AT24C02.h I2C.c I2C.h oled.c oled.h
